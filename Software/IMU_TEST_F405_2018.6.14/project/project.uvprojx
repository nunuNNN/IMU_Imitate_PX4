# Keil uVision project project.uvprojx, settings and files
target STM32F405RG (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F401xx, USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\User;..\Public;..\BSP;..\ekff;..\DRV;..\MotorCtrl;..\FWLIB\STM32_USB_Device_Library\Class\cdc\inc;..\FWLIB\STM32_USB_Device_Library\Core\inc;..\FWLIB\STM32_USB_OTG_Driver\inc;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\FWLIB\CMSIS\Include;..\FWLIB\CMSIS\Device\ST\STM32F4xx;..\FWLIB\CMSIS\Device\ST\STM32F4xx\Include;..\BSP\USB_VCP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: AppComm.c AppMain.c main.c AppIMU.c AppComm.h AppIMU.h AppMain.h AppTimer.h AppCommToPC.c AppTimer.c
  group Fwlib
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_adc.c
  group Cmsis
    ../FWLIB/CMSIS/Device/ST/STM32F4xx/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../FWLIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../FWLIB/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../FWLIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Public
    ../Public/: public.c public.h sysTick.c sysTick.h miniMatrix.c miniMatrix.h
  group UsbDrive
    ../FWLIB/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_dcd_int.c usb_core.c
  group UsbDevice
    ../FWLIB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../FWLIB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group BSP
    ../BSP/: BspSoftI2C.c BspSoftI2C.h BspUart.c BspUart.h stmHead.h BspSpi.c BspSpi.h BspTim.c BspTim.h
    ../BSP/USB_VCP/: usb_bsp.c usb_conf.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_usr.c
  group DRV
    ../DRV/: DrvMPU6500.c DrvMPU6500.h DrvIMU.c DrvIMU.h DrvTim.c DrvTim.h DrvCom.c DrvUSB.c DrvCom.h DrvUSB.h DrvGpio.c DrvGpio.h
  group EKFF
    ../ekff/: miniEKF.c miniEKF.h
