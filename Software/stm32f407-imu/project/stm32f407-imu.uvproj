# Keil uVision project stm32f407-imu.uvproj, settings and files
target stm32f407-imu (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407-imu +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx
  c include: ..\Libraries\FWLIB\inc;..\Libraries\CMSIS;..\Drivers\inc;..\Application\inc;..\Common\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/src/: main.c stm32f4_rcc.c stm32f4_delay.c stm32f4_serial.c stm32f4_icm20689.c
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Drivers
    ../Drivers/src/: stm32f4_usart.c stm32f4_exti.c stm32f4_spi.c
  group Common
    ../Common/src/: Memory.c
